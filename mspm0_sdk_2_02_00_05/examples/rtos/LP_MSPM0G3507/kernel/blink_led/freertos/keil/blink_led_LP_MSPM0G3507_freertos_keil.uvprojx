# Keil uVision project blink_led_LP_MSPM0G3507_freertos_keil.uvprojx, settings and files
target blink_led_LP_MSPM0G3507_freertos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blink_led_LP_MSPM0G3507_freertos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../../tools/keil/syscfg.bat '$P' blink_led.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..;..\..\app;..\..\bsp;..\..\Algorithm;../../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../../kernel/freertos/Source/include;../../../../../../../source;../../../../../../../kernel/freertos/Source/portable/GCC/ARM_CM0;../../../../../../../kernel/freertos/builds/LP_MSPM0G3507/release
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a ../../../../../../../kernel/freertos/builds/LP_MSPM0G3507/release/keil/Objects/freertos_builds_LP_MSPM0G3507_release_keil.lib
  group Source
    ../../: main.c main-blinky.c blink_led.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group BSP
    ../../bsp/: bsp_board.c bsp_board.h bsp_watchdog.c bsp_watchdog.h bsp_buzzer.c bsp_buzzer.h bsp_encoder.c bsp_encoder.h bsp_key.c bsp_key.h bsp_led.c bsp_led.h bsp_motor.c bsp_motor.h bsp_uart.c bsp_uart.h bsp_oled.c bsp_oled.h bsp_yabo_IMU.c bsp_yabo_IMU.h bsp_jy901s.c bsp_jy901s.h bsp_jy61s.c bsp_jy61s.h bsp_bluetooth.c bsp_bluetooth.h bsp_servo.c bsp_servo.h bsp_i2c.c bsp_i2c.h bsp_spi.c bsp_spi.h bsp_track.c bsp_track.h bsp_ZDT.c bsp_ZDT.h
  group Algorithm
    ../../Algorithm/: pid.c pid.h
  group APP
    ../../app/: app_chassis.c app_chassis.h app_watchdog.c app_watchdog.h app_oled_task.c app_oled_task.h app_task_state_machine.c app_task_state_machine.h app_ZDT_task.c app_ZDT_task.h
