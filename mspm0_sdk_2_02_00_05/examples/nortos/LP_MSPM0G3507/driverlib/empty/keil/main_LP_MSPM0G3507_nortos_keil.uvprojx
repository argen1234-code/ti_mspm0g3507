# Keil uVision project main_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target main_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: main_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' main.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../kernel/freertos/Source/include;../../../../../../source;../../../../../../kernel/freertos/Source/portable/GCC/ARM_CM0;../../../../../../kernel/freertos/builds/LP_MSPM0G3507/release;..\APP;..\BSP;..\Algorithm;..\System;..\DMP
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a ../../../../../../kernel/freertos/builds/LP_MSPM0G3507/release/keil/Objects/freertos_builds_LP_MSPM0G3507_release_keil.lib
  group Source
    ../: main.c main.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group APP
    ../APP/: app_chassis.c app_chassis.h
  group BSP
    ../BSP/: bsp_encoder.c bsp_encoder.h bsp_iic.c bsp_iic.h bsp_motor.c bsp_motor.h bsp_mpu6050.c bsp_mpu6050.h bsp_oled.c bsp_oled.h bsp_oled_font.h
  group Algorithm
    ../Algorithm/: pid.c pid.h
  group DMP
    ../DMP/: inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h dmpKey.h dmpmap.h
